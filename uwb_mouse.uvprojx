# Keil uVision project uwb_mouse.uvprojx, settings and files
target Target 1 (6110000::V6.11::.\ARMCLANG)
  device: ING91600 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: IROM(0x2000000-0x21fffff) IRAM(0x20000000-0x20007fff) CPUTYPE("Cortex-M4") FPU2 CLOCK(12800000) ELITTLE
  output: uwb_mouse +hex
  AfterMake: fromelf.exe --bin -o uwb_mouse.bin ./output/uwb_mouse.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: sdk/bundles/typical/inc;sdk/bundles/typical/inc/os;sdk/src/BSP;sdk/src/FWlib;sdk/src/StartUP/ing916;sdk/src/Tools;sdk/src;.\algorithm;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x202a000 size 0x56000
  memory RVCT9: RAM 0x20005420 size 0x2be0
  group APP
    ./src/: main.c button.c
    ./sdk/src/BSP/: bsp_usb_hid.c
  group StartUP
    ./src/: startup_ing91600.s
    sdk/bundles/typical/ING9168xx/: symdefs.m
  group BSP
    sdk/src/BSP/: eflash.c
    ./src/: sc7i22.c uwb.c
    ./sdk/src/BSP/: iic.c
  group FWlib
    sdk/src/FWlib/: peripheral_adc.c peripheral_gpio.c peripheral_i2c.c peripheral_pinctrl.c peripheral_pwm.c peripheral_rtc.c peripheral_ssp.c peripheral_sysctrl.c peripheral_timer.c peripheral_uart.c peripheral_comparator.c peripheral_dma.c peripheral_efuse.c peripheral_i2s.c peripheral_ir.c peripheral_keyscan.c peripheral_pdm.c peripheral_pte.c peripheral_qdec.c peripheral_usb.c
  group Tools
    sdk/src/Tools/: trace.c
  group Algorithm
    ./algorithm/: algo_interfaces.c kalman.c my_mat.c my_math.c attitude_calculator.c my_queue.c mouse.c uwb_data_parser.c algo_main.c imu_data_parser.c
software components: CMSIS:CORE 4.3.0
